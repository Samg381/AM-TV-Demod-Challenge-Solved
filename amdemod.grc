options:
  parameters:
    author: Sam
    generate_options: qt_gui
    id: amdemod
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {state: disabled}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: C:\Users\Sam\Desktop\decoder\iq.wav
    repeat: 'True'
  states: {state: disabled}
- name: blocks_wavfile_source_0_0
  id: blocks_wavfile_source
  parameters:
    file: C:\Users\Sam\Desktop\decoder\iq.wav
    repeat: 'True'
  states: {}
- name: blocks_wavfile_source_0_1
  id: blocks_wavfile_source
  parameters:
    file: C:\Users\Sam\Desktop\decoder\iq.wav
    nchan: '2'
    repeat: 'True'
  states: {state: disabled}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_float_to_complex_0, '1']
- [blocks_float_to_complex_0, '0', blocks_throttle2_0, '0']
- [blocks_float_to_complex_0_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', qtgui_sink_x_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0_0, '0', blocks_throttle2_0, '0']
- [blocks_wavfile_source_0_1, '0', blocks_float_to_complex_0_0, '0']
- [blocks_wavfile_source_0_1, '1', blocks_float_to_complex_0_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
